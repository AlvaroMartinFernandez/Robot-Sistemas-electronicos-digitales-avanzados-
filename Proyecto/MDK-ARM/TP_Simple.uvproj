# Keil uVision project TP_Simple.uvproj, settings and files
target MiniDK2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: TP_Simple +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport;..\Libraries\GLCD;..\Libraries\TouchPanel;..\USER;..\Libraries\LPC1700CMSIS_Firmware_Library\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ../Libraries/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CM3/DeviceSupport/: startup_LPC17xx.s system_LPC17xx.c
  group GLCD
    ../Libraries/GLCD/: AsciiLib.c GLCD.c
  group TouchPanel
    ../Libraries/TouchPanel/: TouchPanel.c
  group UserCode
    ../USER/: tp_simple.c PWM.c main.c StateChar.c i2c_lpc17xx.c Nunchuck.c ADC.c Timer.c DAC.c Interrupciones.c uart.c Bluetooth.c HTTP_CGI.c Watchdog.c
  group Cabeceras
    ../USER/: Interrupciones.h Bluetooth.h Nunchuck.h uart.h DAC.h Timer.h ADC.h tp_simple.h PWM.h i2c_lpc17xx.h StateChar.h audio_muestras.h EMAC_LPC17xx_LAN8720.h Net_Config.h RTL.h Serial.h lpc17xx_libcfg.h Watchdog.h
  group NetFiles
    ../USER/: EMAC_LPC17xx_LAN8720.c TCP_CM3.lib TCPD_CM3.lib Net_Config.c Net_Debug.c
  group Serial
    ../USER/: Serial.c
  group WebData
    ../Web/: index.cgi Web.c Web.inp
